# Repository zagerx/MoDriver_HW_Driver

## KiCad design DriverBoard.kicad_pcb

Parts:
J1, J2: Conn_02x07_Odd_Even; PinSocket_2x07_P1.27mm_Vertical_SMD

Connections:
+3V3: J2.11; also elsewhere on the board
+5V: J2.9; also elsewhere on the board
/BusVoltage: J1.7; also elsewhere on the board
/MOTOR1_ADC_U: J1.1; also elsewhere on the board
/MOTOR1_ADC_V: J1.3; also elsewhere on the board
/MOTOR1_ADC_W: J1.5; also elsewhere on the board
/MOTOR1_BREAK: J1.11
/MOTOR1_U+: J1.2; also elsewhere on the board
/MOTOR1_U-: J1.4, J1.12; also elsewhere on the board
/MOTOR1_V+: J1.6; also elsewhere on the board
/MOTOR1_V-: J1.8; also elsewhere on the board
/MOTOR1_W+: J1.10; also elsewhere on the board
/MOTOR2_ADC_U: J2.1; also elsewhere on the board
/MOTOR2_ADC_V: J2.3; also elsewhere on the board
/MOTOR2_ADC_W: J2.5; also elsewhere on the board
/MOTOR2_BREAK: J2.7
/MOTOR2_U+: J2.2; also elsewhere on the board
/MOTOR2_U-: J2.4; also elsewhere on the board
/MOTOR2_V+: J2.6; also elsewhere on the board
/MOTOR2_V-: J2.8; also elsewhere on the board
/MOTOR2_W+: J2.10; also elsewhere on the board
/MOTOR2_W-: J2.12; also elsewhere on the board
/busCurrent: J1.9
GND: J1.14, J2.13; also elsewhere on the board

Parts:
C20, C21, C22, C27, C45, C46, C47: 0.1uF/100V; C_0603_1608Metric
C23, C24, C25, C26, C28, C29: 4.7uF; C_1206_3216Metric
D2, D3, D4, D5, D6, D7, D14, D15, D16, D17, D18, D19: SODF107-SH; D_SOD-123F
MOTOR1, MOTOR2: Conn_01x03; MR30PW-FB_1x03_P3.50mm_Horizontal
Q1, Q2, Q3, Q4, Q5, Q6, Q7, Q8, Q9, Q10, Q11, Q12: HYG025N06LS1C2; HYG025N06LS1C2-PDFN-8-1EP_6x5mm_P1.27mm_EP3x3mm
R15, R16, R18, R19, R21, R22, R39, R40, R42, R43, R45, R46: 100R; R_0603_1608Metric
R17, R20, R23, R41, R44, R47: 5mR; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder

Connections:
/Pre_Driver/U1: MOTOR1.1, Q1.S, Q2.D; also elsewhere on the board
/Pre_Driver/U1_OUT_H: D2.1 (K), R15.1; also elsewhere on the board
/Pre_Driver/U1_OUT_L: D3.1 (K), R16.1; also elsewhere on the board
/Pre_Driver/U2: MOTOR2.1, Q7.S, Q8.D; also elsewhere on the board
/Pre_Driver/U2_OUT_H: D14.1 (K), R39.1; also elsewhere on the board
/Pre_Driver/U2_OUT_L: D15.1 (K), R40.1; also elsewhere on the board
/Pre_Driver/V1: MOTOR1.2, Q3.S, Q4.D; also elsewhere on the board
/Pre_Driver/V1_OUT_H: D4.1 (K), R18.1; also elsewhere on the board
/Pre_Driver/V1_OUT_L: D5.1 (K), R19.1; also elsewhere on the board
/Pre_Driver/V2: MOTOR2.2, Q9.S, Q10.D; also elsewhere on the board
/Pre_Driver/V2_OUT_H: D16.1 (K), R42.1; also elsewhere on the board
/Pre_Driver/V2_OUT_L: D17.1 (K), R43.1; also elsewhere on the board
/Pre_Driver/W1: MOTOR1.3, Q5.S, Q6.D; also elsewhere on the board
/Pre_Driver/W1_OUT_H: D6.1 (K), R21.1; also elsewhere on the board
/Pre_Driver/W1_OUT_L: D7.1 (K), R22.1; also elsewhere on the board
/Pre_Driver/W2: MOTOR2.3, Q11.S, Q12.D; also elsewhere on the board
/Pre_Driver/W2_OUT_H: D18.1 (K), R45.1; also elsewhere on the board
/Pre_Driver/W2_OUT_L: D19.1 (K), R46.1; also elsewhere on the board
/ThreePhase/U1_CURR: C20.2, Q2.S, R17.1; also elsewhere on the board
/ThreePhase/U2_CURR: C45.2, Q8.S, R41.1; also elsewhere on the board
/ThreePhase/V1_CURR: C21.2, Q4.S, R20.1; also elsewhere on the board
/ThreePhase/V2_CURR: C46.2, Q10.S, R44.1; also elsewhere on the board
/ThreePhase/W1_CURR: C22.2, Q6.S, R23.1; also elsewhere on the board
/ThreePhase/W2_CURR: C47.2, Q12.S, R47.1; also elsewhere on the board
GND: C27.1; also elsewhere on the board
GNDPWR: C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, R17.2, R20.2, R23.2, R41.2, R44.2, R47.2
unnamed: D2.2 (A), Q1.G, R15.2
unnamed: D3.2 (A), Q2.G, R16.2
unnamed: D4.2 (A), Q3.G, R18.2
unnamed: D5.2 (A), Q4.G, R19.2
unnamed: D6.2 (A), Q5.G, R21.2
unnamed: D7.2 (A), Q6.G, R22.2
unnamed: D14.2 (A), Q7.G, R39.2
unnamed: D15.2 (A), Q8.G, R40.2
unnamed: D16.2 (A), Q9.G, R42.2
unnamed: D17.2 (A), Q10.G, R43.2
unnamed: D18.2 (A), Q11.G, R45.2
unnamed: D19.2 (A), Q12.G, R46.2
VDC: C20.1, C21.1, C22.1, C23.1, C24.1, C25.1, C26.1, C28.1, C29.1, C45.1, C46.1, C47.1, Q1.D, Q3.D, Q5.D, Q7.D, Q9.D, Q11.D; also elsewhere on the board

Parts:
C34, C36, C37, C38, C39, C40, C48, C50, C51, C52, C53, C54: NC; C_0603_1608Metric
C35, C49: 1nF; C_0603_1608Metric
R24, R25, R48, R49: 4.7K; R_0603_1608Metric
R26, R31, R35, R50, R55, R59: 6.8K; R_0603_1608Metric
R27, R32, R36, R51, R56, R60: 1K(1%); R_0603_1608Metric
R28, R33, R37, R52, R57, R61: 4.7K(1%); R_0603_1608Metric
R29, R34, R38, R53, R58, R62: 0R; R_0603_1608Metric
R30, R54: 0.01R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U5, U7: SSOP-14_5.3x6.2mm_P0.65mm

Connections:
+3V3: C35.1, C49.1, R25.1, R49.1, U5.11 (G), U7.11 (G); also elsewhere on the board
/MOTOR1_ADC_U: C36.2, R29.2; also elsewhere on the board
/MOTOR1_ADC_V: C38.2, R34.2; also elsewhere on the board
/MOTOR1_ADC_W: C40.2, R38.2; also elsewhere on the board
/MOTOR2_ADC_U: C50.2, R53.2; also elsewhere on the board
/MOTOR2_ADC_V: C52.2, R58.2; also elsewhere on the board
/MOTOR2_ADC_W: C54.2, R62.2; also elsewhere on the board
/ThreePhase/U1_CURR: R26.2, U5.2 (-); also elsewhere on the board
/ThreePhase/U2_CURR: R50.2, U7.2 (-); also elsewhere on the board
/ThreePhase/V1_CURR: R31.2, U5.6 (-); also elsewhere on the board
/ThreePhase/V2_CURR: R55.2, U7.6 (-); also elsewhere on the board
/ThreePhase/W1_CURR: R35.2, U5.9 (-); also elsewhere on the board
/ThreePhase/W2_CURR: R59.2, U7.9 (-); also elsewhere on the board
GND: C35.2, C36.1, C38.1, C40.1, C49.2, C50.1, C52.1, C54.1, R24.2, R27.1, R32.1, R36.1, R48.2, R51.1, R56.1, R60.1, U5.4 (V), U7.4 (V); also elsewhere on the board
unnamed: C34.2, R28.2, R29.1, U5.1
unnamed: C37.2, R33.2, R34.1, U5.7
unnamed: C48.2, R52.2, R53.1, U7.1
unnamed: C51.2, R57.2, R58.1, U7.7
unnamed: C34.1, R27.2, R28.1, U5.3 (+)
unnamed: C37.1, R32.2, R33.1, U5.5 (+)
unnamed: C39.2, R37.2, R38.1, U5.8 (11)
unnamed: C39.1, R36.2, R37.1, U5.10 (+)
unnamed: R30.2, U5.12 (+), U5.14 (D_O)
unnamed: R24.1, R25.2, U5.13 (-)
unnamed: C48.1, R51.2, R52.1, U7.3 (+)
unnamed: C51.1, R56.2, R57.1, U7.5 (+)
unnamed: C53.2, R61.2, R62.1, U7.8 (11)
unnamed: C53.1, R60.2, R61.1, U7.10 (+)
unnamed: R54.2, U7.12 (+), U7.14 (D_O)
unnamed: R48.1, R49.2, U7.13 (-)
Vref: R26.1, R30.1, R31.1, R35.1, R50.1, R54.1, R55.1, R59.1

Notes on the sheet:
1.65V基准电压

Parts:
C30, C31, C32, C33, C41, C42, C43, C44: 0.47uF; C_0805_2012Metric
D8, D9, D10, D11, D12, D13: SODF107-SH; D_SOD-123F
U4, U6: FD6288T; TSSOP-20_4.4x5mm_P0.5mm

Connections:
+12V: C30.2, C41.2, D8.2 (A), D9.2 (A), D10.2 (A), D11.2 (A), D12.2 (A), D13.2 (A), U4.7 (VCC), U4.14 (VB3), U4.17 (VB2), U4.20 (VB1), U6.7 (VCC), U6.14 (VB3), U6.17 (VB2), U6.20 (VB1); also elsewhere on the board
/MOTOR1_U+: U4.1 (HIN1); also elsewhere on the board
/MOTOR1_U-: U4.4 (LIN1), U4.6 (LIN3); also elsewhere on the board
/MOTOR1_V+: U4.2 (HIN2); also elsewhere on the board
/MOTOR1_V-: U4.5 (LIN2); also elsewhere on the board
/MOTOR1_W+: U4.3 (HIN3); also elsewhere on the board
/MOTOR2_U+: U6.1 (HIN1); also elsewhere on the board
/MOTOR2_U-: U6.4 (LIN1); also elsewhere on the board
/MOTOR2_V+: U6.2 (HIN2); also elsewhere on the board
/MOTOR2_V-: U6.5 (LIN2); also elsewhere on the board
/MOTOR2_W+: U6.3 (HIN3); also elsewhere on the board
/MOTOR2_W-: U6.6 (LIN3); also elsewhere on the board
/Pre_Driver/U1: C31.1, U4.18 (VS1); also elsewhere on the board
/Pre_Driver/U1_OUT_H: U4.19 (HO1); also elsewhere on the board
/Pre_Driver/U1_OUT_L: U4.11 (LO1); also elsewhere on the board
/Pre_Driver/U2: C42.1, U6.18 (VS1); also elsewhere on the board
/Pre_Driver/U2_OUT_H: U6.19 (HO1); also elsewhere on the board
/Pre_Driver/U2_OUT_L: U6.11 (LO1); also elsewhere on the board
/Pre_Driver/V1: C32.1, U4.15 (VS2); also elsewhere on the board
/Pre_Driver/V1_OUT_H: U4.16 (HO2); also elsewhere on the board
/Pre_Driver/V1_OUT_L: U4.10 (LO2); also elsewhere on the board
/Pre_Driver/V2: C43.1, U6.15 (VS2); also elsewhere on the board
/Pre_Driver/V2_OUT_H: U6.16 (HO2); also elsewhere on the board
/Pre_Driver/V2_OUT_L: U6.10 (LO2); also elsewhere on the board
/Pre_Driver/W1: C33.1, U4.12 (VS3); also elsewhere on the board
/Pre_Driver/W1_OUT_H: U4.9 (LO3); also elsewhere on the board
/Pre_Driver/W1_OUT_L: U4.13 (HO3); also elsewhere on the board
/Pre_Driver/W2: C44.1, U6.12 (VS3); also elsewhere on the board
/Pre_Driver/W2_OUT_H: U6.9 (LO3); also elsewhere on the board
/Pre_Driver/W2_OUT_L: U6.13 (HO3); also elsewhere on the board
GND: C30.1, C41.1, U4.8 (COM), U6.8 (COM); also elsewhere on the board
unnamed: C31.2, D8.1 (K)
unnamed: C32.2, D9.1 (K)
unnamed: C33.2, D10.1 (K)
unnamed: C42.2, D11.1 (K)
unnamed: C43.2, D12.1 (K)
unnamed: C44.2, D13.1 (K)

Parts:
C1, C2, C3: 4.7uF; C_0603_1608Metric
C4, C9, C12, C15, C19: 0.1uF; C_0603_1608Metric
C5, C6, C7, C8: 2.2uF; C_0603_1608Metric
C10: 22nF; C_0603_1608Metric
C11: 4.7nF; C_0603_1608Metric
C13, C14, C17, C18: 47uF; C_1210_3225Metric
C16: 1nF; C_0603_1608Metric
D1: B360B-13-F; D_SMB
L1: 10uH; L_APV_APH0650
L2: 33uH; L_APV_APH0650
R1, R4: 180K; R_0603_1608Metric
R2, R5: 43K; R_0603_1608Metric
R3, R6: 200K; R_0603_1608Metric
R7: 20K; R_0603_1608Metric
R8, R9: 53.6K; R_0603_1608Metric
R10, R12: 10.2K; R_0603_1608Metric
R11: 143K; R_0603_1608Metric
R13, R14: 10K; R_0603_1608Metric
U1: XT30PW-F_1x02_P2.50mm_Horizontal
U2: SCT2420; SOIC-8_5.3x6.2mm_P1.27mm
U3: SCT2610; MSOP-10-1EP_3x3mm_P0.5mm_EP1.68x1.88mm

Connections:
+5V: C13.1, C14.1, C15.1, L1.2, R9.1; also elsewhere on the board
+12V: C1.1, C2.1, C3.1, C4.1, C17.1, C18.1, L2.2, R1.1, R11.1, U2.2 (VIN); also elsewhere on the board
/BusVoltage: C19.1, R13.1, R14.2; also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C10.2, C11.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, D1.2 (A), R2.1, R3.1, R5.1, R6.1, R10.2, R12.2, R14.1, U1.2 (N), U2.7 (GND), U3.8 (GND), U3.11 (EP); also elsewhere on the board
unnamed: C11.1, R7.1
unnamed: C16.1, R8.1
unnamed: C12.2, D1.1 (K), L2.1, U3.10 (SW)
unnamed: C9.1, U2.1 (BOOT)
unnamed: R7.2, U2.6 (COMP)
unnamed: R1.2, R2.2, U2.3 (EN)
unnamed: R9.2, R10.1, U2.5 (FB)
unnamed: R3.2, U2.4 (RT/CLK)
unnamed: C9.2, L1.1, U2.8 (SW)
unnamed: C12.1, U3.1 (BOOT)
unnamed: R8.2, U3.9 (COMP)
unnamed: R4.2, R5.2, U3.3 (EN)
unnamed: R11.2, R12.1, U3.7 (FB)
unnamed: R6.2, U3.5 (RT/CLK)
unnamed: C10.1, U3.4 (SS/TR)
VDC: C5.1, C6.1, C7.1, C8.1, R4.1, R13.2, U1.1, U3.2 (VIN); also elsewhere on the board

Notes on the sheet:
DC/DC 12V转5V
DC/DC 24V转12V
Vout:5V/2.0A
Vout:12V/1.5A

Board: 4 copper layers, 80.0 x 60.0 mm, 160 parts (0 on the bottom side), 98 nets.

## Commit log

2025-07-31 增加kicad工程
2025-07-31 增加忽略文件
2025-07-31 原理图:完成接口部分
2025-08-01 增加部分接口
2025-08-04 增加预驱/三相桥电路
2025-08-08 优化电源原理图设计
2025-08-08 优化5V电源/预驱电路/三相桥/运放
2025-08-10 分配部分封装
2025-08-11 生成网表并添加到PCB
2025-08-13 工程增加环境变量
2025-08-13 增加DXF文件夹
2025-08-14 三相桥基极增加回流路径,增加VDC的输入电容
2025-08-14 优化原理图
2025-08-17 修改板框文件
2025-08-19 优化电源布局,优化中
2025-08-21 布局初步结束
2025-08-22 原理图增加motor2部分
